SUMMARY = "Qt Calculator App"
LICENSE = "MIT"
PR = "r1"
inherit packagegroup
#PACKAGES = "${PN}"

RDEPENDS:${PN} = "qtcalculator"
